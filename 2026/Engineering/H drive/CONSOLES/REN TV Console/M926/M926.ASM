	ERRORLEVEL -302
;      M926 fader MODULE

	LIST	P=16C73A
	#INCLUDE "P16C73A.INC"


;************ CPU CONTROL MACROS **********

BANK0	MACRO
	BCF STATUS,5
	ENDM

BANK1	MACRO
	BSF STATUS,5
	ENDM

BINIT	EQU 0X4F
;************ PROGRAM  MACROS **********



;*************  BANK0  RAM *****************
	ORG 20H 	;BANK0 MEMORY 


;	74HC4094 OUTPUT TABLE - SENT OUT IN 'REFRESH' ROUTINE

SHOUT0	RES 1	;FIRST OUT - LSB FIRST
SHOUT1	RES 1	;
SHOUT2	RES 1	;	
SHOUT3	RES 1	;LAST OUT

SEL0	RES 1	;
SEL1	RES 1
SEL2	RES 1


BOUNCE	RES 1	;DEBOUNCE COUNTER
DBNC	RES 1	;DEBOUNCE COUNTER FOR MAIN ROUTINE
BOUNCE0	RES 1	;SAVE PREV PB STATUS HERE FOR DEBOUNCE
BOUNCE1	RES 1
BOUNCE2	RES 1



;	TEMP RAM REGISTERS
TEMP1	RES 1
TEMP2	RES 1



DELAY1	RES 1		;TEMP REG FOR DELAY ROUTINES
DELAY2	RES 1		;TEMP REG FOR DELAY ROUTINES
;SCNSEL	EQU 43		;KEEPS TRACK OF CURRENT SCAN LINE
;SCNWT	EQU 44		;SCAN DELAY FOR MUXING XPT ROUTINES * INIT VALUE

Z	EQU 2		;ZER0 FLAG IN STATUS REG
;

; MACROS ACTIVATE BITS FOR SHOUT(SHIFT OUT) TABLE TABLE


;********************  BANK 1 FILE REISTERS*****************


;    160 THROUGH 256 ARE GENERAL PURPOSE REGISTERS




;***************  RESET  ****************************

	ORG 0
        CALL INIT
	GOTO MAIN

;*************	INTERRUPTS  *************************

	ORG 4H
	RETFIE

;************** INIT  ******************************

INIT	BSF PORTC,0	;STROBE OUTPUT IS 1
	BANK1
	BCF TRISA,4	;STROBE PIN IS OUTPUT
 	BCF TRISA,5	;CLOCK PIN IS OUTPUT
	BCF TRISC,6	;DATA OUT/HC165 STROBE IS OUTPUT
	BCF TRISA,0	;DAC CS
	BCF TRISA,1	;DAC DATA
	BCF TRISA,2	;DAC CLK

	;BCF TRISA,2	;DATAA PIN IS OUTPUT
	BSF ADCON1,PCFG2	;porta is digital i/o
	BSF ADCON1,PCFG1

	BANK0
	MOVLW 0
	MOVWF SEL0
	MOVWF SEL1
	MOVWF SEL2

	MOVWF BOUNCE0
	MOVWF BOUNCE1
	MOVWF BOUNCE2

	MOVLW 0XFF
	MOVWF SHOUT0
	MOVWF DBNC	
	MOVWF SHOUT0
	MOVWF SHOUT1
	MOVWF SHOUT2
	MOVWF SHOUT3
	CALL REFRESH	
	

;	BCF SHOUT7,6	;DEFAULT TO STEREO MODE
;	BCF SHOUT8,4	;DEFAULT TO A INPUT
	CALL REFRESH
	RETURN
	

;**************  MAIN  ******************************

MAIN  

	CALL SCAN
	CALL PROCESS
	CALL REFRESH


;	CALL DELL
	GOTO MAIN

dell	
	
	
	MOVLW 0X1
	MOVWF DELAY2
	CALL DELAY
	
	return



;**************  SCAN  PUSH BUTTON ROUTINE ***********************

; 
SCAN	

	CLRF SEL0
	CLRF SEL1
	BCF  SEL2,0
	BCF PORTA,3	;CLOCK IS LOW
	BSF PORTC,6	;STROBE DATA INTO 74HC165'S
	BCF PORTC,6
	BSF PORTC,6
	
;SEL0
	BTFSS PORTC,7
	BSF SEL0,0
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3	

	BTFSS PORTC,7
	BSF SEL0,1
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL0,2
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL0,3
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL0,4
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL0,5
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL0,6
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL0,7
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3	
;SEL1
	BTFSS PORTC,7
	BSF SEL1,0
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3	

	BTFSS PORTC,7
	BSF SEL1,1
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL1,2
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL1,3
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL1,4
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL1,5
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL1,6
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3

	BTFSS PORTC,7
	BSF SEL1,7
	BSF PORTA,3	;CLOCK PULSE
	BCF PORTA,3	

;SEL2	-BIT0 IS CURRENT SCAN
;	-BIT1 IS PREVIOUS SCAN
;	-BIT2 INDICATES DEBOUNCE STATE		

	BTFSS PORTC,7	;EOT
	GOTO EOTIS0
	BTFSC SEL2,1
	GOTO NOCH	;NOT CHANGED
	BSF SEL2,1
	GOTO EOTCH
EOTIS0	
	BTFSS SEL2,1
	GOTO NOCH	;NOT CHANGED
	BCF SEL2,1

EOTCH	
;	BTFSC SEL2,2	;IF IN DEBOUNCE IGNORE CHANGE
	BSF SEL2,7	
	BSF SEL2,0
	RETURN
NOCH	


;WAS THERE A CLOSURE

	MOVF SEL0,W
	BTFSS STATUS,Z
	GOTO NOTZERO
	MOVF SEL1,W
	BTFSS STATUS,Z
	GOTO NOTZERO


;MUST BE ZERO
	
	DECFSZ BOUNCE,F
	RETURN

	BCF SEL2,6
	BCF SEL2,7
	MOVLW BINIT
	MOVWF BOUNCE
	RETURN

NOTZERO		;CLOSURE DETECTED

;COMPARE SCAN/BOUNCE

	BTFSS SEL2,6
	GOTO	COMP	;WAIT FOR PB RELEASE
	MOVLW BINIT
	MOVWF BOUNCE
	RETURN


COMP	MOVF SEL0,W
	XORWF BOUNCE0,W
	BTFSS STATUS,Z
	GOTO NOTEQUAL
	
	MOVF SEL1,W
	XORWF BOUNCE1,W
	BTFSS STATUS,Z
	GOTO NOTEQUAL



;MUST BE EQUAL
	DECFSZ BOUNCE,F
	RETURN
	BSF SEL2,7
	MOVLW BINIT
	MOVWF BOUNCE	;RESET DEBOUNCE COUNT

	CLRF BOUNCE0
	CLRF BOUNCE1

	RETURN
NOTEQUAL

	MOVF SEL0,W
	MOVWF BOUNCE0

	MOVF SEL1,W
	MOVWF BOUNCE1

	MOVLW BINIT
	MOVWF BOUNCE
	RETURN

	
;**************    PUSH BUTTON processing  ***********************


PROCESS	
	BTFSS SEL2,7
	RETURN		; NO CLOSURES TO PROCESS
	BSF SEL2,6	;FLAG - WAIT FOR PB RELEASE IN SCAN
	BCF SEL2,7	;CLEAR CLOSURE FLAG

; TEST SEL0-SEL2 FOR PUSH BUTTON CLOSURES
;SEL0
	BTFSC SEL0,0	;
	CALL SOLO
	BTFSC SEL0,1	;
	CALL AUTO
	BTFSC SEL0,2	;
	CALL SLV1
	BTFSC SEL0,3	;
	CALL SLV2
	BTFSC SEL0,4	;
	CALL MASTER
	BTFSC SEL0,5	;
	CALL SLV4
	BTFSC SEL0,6	;
	CALL SLV3
	BTFSC SEL0,7	;
	CALL PFL
;SEL1
	BTFSC SEL1,0	;
	CALL EXT
	BTFSC SEL1,1	;
	CALL SELA
	BTFSC SEL1,2	;
	CALL SENDA
	BTFSC SEL1,3	;
	CALL SELB
	BTFSC SEL1,4	;
	CALL LCL
	BTFSC SEL1,5	;
	CALL MMSOLO
	BTFSC SEL1,6	;
	CALL SENDB
	BTFSC SEL1,7	;
	CALL CHON	
	
	BTFSC SEL2,0
	CALL EOT
	BSF SHOUT2,4
	BTFSC SHOUT2,0	;IS MASTER ON
	RETURN		;MUST BE OFF
	
	BTFSS SHOUT1,7	;turn slaves off
	GOTO SLVD
	BTFSS SHOUT1,3
	GOTO SLVD
	BTFSS SHOUT1,6
	GOTO SLVD
	BTFSS SHOUT1,2	
	GOTO SLVD
	BSF SHOUT2,4
	RETURN

SLVD	BCF SHOUT2,4	;TURN ON INFINITE LED
	RETURN
;-------------------------------------
SOLO	
	bsf shout3,0	;turn off mmsolo
	BTFSC SHOUT1,1
	GOTO SOLOFF
	BSF SHOUT1,1
	return
SOLOFF	BCF SHOUT1,1
	RETURN
;-------------------------------------
AUTO	RETURN

;-------------------------------------
EOT
	BSF SHOUT1,5

	RETURN
		


;--------------------------------------
SLV1
	
			;turn slaves off
	BSF SHOUT1,3
	BSF SHOUT1,6
	BSF SHOUT1,2		
	BTFSC SHOUT1,7
	GOTO SLV1OFF
	BSF SHOUT1,7
	return
SLV1OFF	
	
	BCF SHOUT1,7

	RETURN

;---------------------------------------	
SLV2
	BSF SHOUT1,7	;turn slaves off

	BSF SHOUT1,6
	BSF SHOUT1,2	
	BTFSC SHOUT1,3
	GOTO SLV2OFF
	BSF SHOUT1,3
	return
SLV2OFF	BCF SHOUT1,3
	RETURN 
		
;--------------------------
SLV3
	BSF SHOUT1,7	;turn slaves off
	BSF SHOUT1,3

	BSF SHOUT1,2	
	BTFSC SHOUT1,6
	GOTO SLV3OFF
	BSF SHOUT1,6
	return
SLV3OFF	BCF SHOUT1,6
	RETURN 
		
;--------------------------
SLV4
	BSF SHOUT1,7	;turn slaves off
	BSF SHOUT1,3
	BSF SHOUT1,6

	BTFSC SHOUT1,2
	GOTO SLV4OFF
	BSF SHOUT1,2
	return
SLV4OFF	BCF SHOUT1,2
	RETURN 

;----------------------------
master
	BTFSC SHOUT2,0
	GOTO MSTROFF
	BSF SHOUT2,0
	BSF SHOUT1,7	;turn slaves off
	BSF SHOUT1,3
	BSF SHOUT1,6
	BSF SHOUT1,2	
	return

MSTROFF	

	BTFSS SHOUT1,7	;IGNORE IF SLAVED
	return
	BTFSS SHOUT1,3
	return
	BTFSS SHOUT1,6
	return
	BTFSS SHOUT1,2
	return
	BCF SHOUT2,0
	RETURN 
		
;---------------------------
pfl
	BTFSC SHOUT1,5
	GOTO PFLOFF
	BSF SHOUT1,5
	return
PFLOFF	BCF SHOUT1,5
	RETURN 
				
;------------------------
EXT	
	BTFSC SHOUT3,1
	GOTO EXTOFF
	BSF SHOUT3,1
	return
EXTOFF	BCF SHOUT3,1
	RETURN 

;------------------------


SELA	
	bsf shout3,2	;turn off selb
	BTFSC SHOUT3,7
	GOTO SELAOFF
	BSF SHOUT3,7
	return
SELAOFF	BCF SHOUT3,7
	RETURN 
				
;-------------------------
SENDA
	BTFSC SHOUT3,3
	GOTO SNDAOFF
	BSF SHOUT3,3
	return
SNDAOFF	BCF SHOUT3,3
	RETURN 
				
;-------------------------
SENDB
	bsf shout3,7	;turn off sela
	BTFSC SHOUT3,6
	GOTO SNDBOFF
	BSF SHOUT3,6
	return
SNDBOFF	BCF SHOUT3,6
	RETURN 
				
;---------------------------
SELB
	bsf shout3,7	;turn off sela
	BTFSC SHOUT3,2
	GOTO SELBOFF
	BSF SHOUT3,2
	return
SELBOFF	BCF SHOUT3,2
	RETURN 
				
;----------------------------

LCL
	BTFSC SHOUT3,5
	GOTO LCLOFF
	BSF SHOUT3,5
	return
LCLOFF	BCF SHOUT3,5
	RETURN 
				
;-----------------------------

MMSOLO
	bsf shout1,1	;turn off solo
	BTFSC SHOUT3,0
	GOTO MMSOFF
	BSF SHOUT3,0
	return
MMSOFF	BCF SHOUT3,0
	RETURN 
				
;------------------------
		
CHON
	
	BTFSC SHOUT3,4
	GOTO CHOFF
	BSF SHOUT3,4
	BSF SHOUT0,1
	return
CHOFF	BCF SHOUT3,4
	BCF SHOUT0,1
	RETURN 
				
;----------------------------


;*******************  REFRESH ***********************************

;     REFRESH  - TRANSMITS CROSSPOINT TABLE TO 74HC4094'S


CLK	EQU 3	; PORTA BIT 3
STR	EQU 4	; PORTA BIT 4
DATAA	EQU 6	;PORTC BIT 6
;TEMP1  TEMP FILE REGISTER	
;TEMP2	BIT COUNT

REFRESH
	BANK1
	BCF TRISC,6	;DATA PIN IS OUTPUT
	BCF TRISA,4	;STROBE PIN IS OUTPUT
 	BCF TRISA,3	;CLOCK PIN IS OUTPUT
	BANK0
	BCF PORTA,CLK
;output shout table
	MOVF SHOUT0,W
	;BTFSS M926-0,X		;IS CHANNEL ON
	;AND W WITH XPT0 ;
	CALL CLKBYTE
	MOVF SHOUT1,W
	CALL CLKBYTE
	MOVF SHOUT2,W
	CALL CLKBYTE
	MOVF SHOUT3,W
	CALL CLKBYTE

	BCF PORTA,STR
	NOP
	BSF PORTA,STR
	BCF PORTA,STR
;	BANK1
;	BSF TRISA,2	;DATAA PIN IS INPUT
;	BANK0
	RETURN

; CLOCK BYTE IN W REGISTER TO 74HC4094'S

CLKBYTE	
	MOVWF TEMP1
	MOVLW 8
	MOVWF TEMP2	;BIT COUNT

NXTBIT	RRF TEMP1,F
	BTFSC STATUS,0
	GOTO ONE
	BCF PORTC,DATAA
	BSF PORTA,CLK
	BCF PORTA,CLK
	DECFSZ TEMP2,F
	GOTO NXTBIT
	RETURN

ONE 	BSF PORTC,DATAA
	BSF PORTA,CLK
	BCF PORTA,CLK
	DECFSZ TEMP2,F
	GOTO NXTBIT
	RETURN

		
;****************  DELAY ROUTINE *****************************


; INIT DELAY 2 BEFORE ENTERING
; DELAY=:: DELAY1(255*1/1.25MHZ*2 * DELAY2)

DELAY
	MOVLW 0XFF
DEL1	MOVWF DELAY1
DEC1	DECFSZ DELAY1,F
	GOTO DEC1
	DECFSZ DELAY2,F
	GOTO DEL1
	RETURN

	;INITIALIZE SHOUT TABLE WITH DEFAULTS



	END
